# This recipe was added as a workaround to handle this error:
# ERROR: No recipes available for:
# zondbox-distro/meta-st-stm32mp/recipes-core/systemd/systemd-conf_243.bbappend

LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/BSD-3-Clause;md5=550794465ba0ec5312d6919e203a55f9"
